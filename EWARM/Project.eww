<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32_DMA_MultiADC_ver2.ewp</path>
  </project>
  <batchBuild />
</workspace>
